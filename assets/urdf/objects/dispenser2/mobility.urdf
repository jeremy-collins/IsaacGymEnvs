Commit message: update dispenser configs

File: assets/urdf/objects/dispenser2/mobility.urdf (robot description, URDF)
Before this commit: robot partnet_2bbbe0e4-7f35-43a1-927c-d4c84e1af737, 6 links, 5 joints
Joints:
- joint joint_0: limit lower=0 upper=0.09 -> lower=0 upper=0.03
