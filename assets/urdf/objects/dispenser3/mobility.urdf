Commit message: update disp 3 limits

File: assets/urdf/objects/dispenser3/mobility.urdf (robot description, URDF)
Before this commit: robot partnet_af3763054969179d5a539e595e9e07ce, 6 links, 5 joints
Joints:
- joint joint_0: limit lower=0 upper=0.175 -> lower=0 upper=0.03
