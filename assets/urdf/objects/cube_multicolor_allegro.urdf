Commit message: fix device_name ref in rlgames_utils

File: assets/urdf/objects/cube_multicolor_allegro.urdf (robot description, URDF)
Before this commit: robot object, 1 links, 0 joints
Links:
- link object: mass None -> 0.0864
