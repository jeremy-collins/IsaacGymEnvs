Commit message: update allegrograsp to train with fingertip cost

File: assets/urdf/objects/pill_bottle/mobility.urdf (robot description, URDF)
Before this commit: robot partnet_77699e08e3824eab47765668cf4023ed, 4 links, 3 joints
Joints:
- joint joint_1: type continuous -> fixed
